# Keil uVision project smart_thermometer.uvproj, settings and files
target main (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: smart_thermometer +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c ds18b20.c startup.a51
  group include
    ./: ds18b20.h
